# Keil uVision project one keys.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: one keys +hex
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ./: STARTUP.A51 main.c sch51.c Key.c Beep.c WS2812.c
  group LIB
    D:/Keil_v5/C51/LIB/: C51S.LIB
